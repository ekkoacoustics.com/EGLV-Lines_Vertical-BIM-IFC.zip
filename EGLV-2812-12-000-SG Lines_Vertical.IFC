Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-2812-12-000-SG Lines_Vertical.IFC
Time: 2024-11-05T12:41:51+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 39.7152000000000598; Volume Measure: 0.0397152000000001; Area Measure: 6.9657789083488275

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 39.7152000000000598; Volume Measure: 0.0397152000000001; Area Measure: 6.9657789083488275

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 39.7152000000000598; Volume Measure: 0.0397152000000001; Area Measure: 6.9657789083488275

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-2812-12-000-SG Lines_Vertical | PSet_Mass_Property - Mass Measure: 39.7152000000000598; Volume Measure: 0.0397152000000001; Area Measure: 6.9657789083488275
EGLV-2812-12-000-SG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV2812-12-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
