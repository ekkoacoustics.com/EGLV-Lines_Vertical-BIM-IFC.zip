Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-2412-9-000-DG Lines_Vertical.IFC
Time: 2024-11-05T12:43:35+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 23.0976000000001704; Volume Measure: 0.0230976000000002; Area Measure: 6.1228698166976550

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 23.0976000000001704; Volume Measure: 0.0230976000000002; Area Measure: 6.1228698166976550

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 23.0976000000001704; Volume Measure: 0.0230976000000002; Area Measure: 6.1228698166976550

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-2412-9-000-DG Lines_Vertical | PSet_Mass_Property - Mass Measure: 23.0976000000001704; Volume Measure: 0.0230976000000002; Area Measure: 6.1228698166976550
EGLV-2412-9-000-DG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
