Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-66-12-000-SG Lines_Vertical.IFC
Time: 2024-11-05T12:43:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 4.2552000000000030; Volume Measure: 0.0042552000000000; Area Measure: 0.7628780258945183

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 4.2552000000000030; Volume Measure: 0.0042552000000000; Area Measure: 0.7628780258945183

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 4.2552000000000030; Volume Measure: 0.0042552000000000; Area Measure: 0.7628780258945183

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-66-12-000-SG Lines_Vertical | PSet_Mass_Property - Mass Measure: 4.2552000000000030; Volume Measure: 0.0042552000000000; Area Measure: 0.7628780258945183
EGLV-66-12-000-SG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV-66-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
