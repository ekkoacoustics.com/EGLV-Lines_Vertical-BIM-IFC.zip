Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-2812-12-000-DG Lines_Vertical.IFC
Time: 2024-11-05T12:42:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 37.0272000000001782; Volume Measure: 0.0370272000000002; Area Measure: 7.1641401194805985

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 37.0272000000001782; Volume Measure: 0.0370272000000002; Area Measure: 7.1641401194805985

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 37.0272000000001782; Volume Measure: 0.0370272000000002; Area Measure: 7.1641401194805985

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-2812-12-000-DG Lines_Vertical | PSet_Mass_Property - Mass Measure: 37.0272000000001782; Volume Measure: 0.0370272000000002; Area Measure: 7.1641401194805985
EGLV-2812-12-000-DG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV-2812-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; DrawnBy: CAM; CheckedBy: DG; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
