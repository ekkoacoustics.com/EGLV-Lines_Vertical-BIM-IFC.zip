Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-66-9-000-SG Lines_Vertical.IFC
Time: 2024-11-05T12:44:25+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 3.1752000000000020; Volume Measure: 0.0031752000000000; Area Measure: 0.7556780258945184

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 3.1752000000000020; Volume Measure: 0.0031752000000000; Area Measure: 0.7556780258945184

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 3.1752000000000020; Volume Measure: 0.0031752000000000; Area Measure: 0.7556780258945184

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-66-9-000-SG Lines_Vertical | PSet_Mass_Property - Mass Measure: 3.1752000000000020; Volume Measure: 0.0031752000000000; Area Measure: 0.7556780258945184
EGLV-66-9-000-SG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV-66-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
