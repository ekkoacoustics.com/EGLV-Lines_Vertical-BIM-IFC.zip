Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Vertical\EGLV-2412-12-000-SG Lines_Vertical.IFC
Time: 2024-11-05T12:42:52+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 34.0416000000000452; Volume Measure: 0.0340416000000000; Area Measure: 5.9747202071561256

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 34.0416000000000452; Volume Measure: 0.0340416000000000; Area Measure: 5.9747202071561256

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 34.0416000000000452; Volume Measure: 0.0340416000000000; Area Measure: 5.9747202071561256

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGLV-2412-12-000-SG Lines_Vertical | PSet_Mass_Property - Mass Measure: 34.0416000000000452; Volume Measure: 0.0340416000000000; Area Measure: 5.9747202071561256
EGLV-2412-12-000-SG Lines_Vertical | SOLIDWORKS Custom Properties - Description: LINES_VERTICAL; PartNo: EGLV-2412-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Project: EKKO PRODUCT LIST; sets with these values: 2
